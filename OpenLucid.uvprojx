# Keil uVision project OpenLucid.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OpenLucid
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F401xx,USE_STM324xG_EVAL
  c misc: -C99
  c include: .\Files\inc;.\Files\sd;.\Files\DSP\Include;.\Files\LoRa
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APP
    ./Files/src/: Delay.c main.c misc.c spi.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_it.c
  group SD
    ./Files/sd/: stm324xg_eval_sdio_sd.c stm324xg_eval.c
  group GSM
    ./Files/src/: GSM.c
  group ADC
    ./Files/src/: ADS1299.c Peripheral_Init.c coeffs_IIR.c IRQ.c
  group DSP
    ./Files/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ./Files/DSP/Source/FilteringFunctions/: arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_f32.c
  group RTC
    ./Files/src/: RTC.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:Startup 2.6.3
